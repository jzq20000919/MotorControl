# Keil uVision project MCSDK_FOC_MIX.uvprojx, settings and files
target MCSDK_FOC_MIX (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: MCSDK_FOC_MIX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/G4xx/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c speed_torq_ctrl.c pwm_common.c mc_api.c mc_config.c mc_config_common.c mcp_config.c mc_tasks.c mc_tasks_foc.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32g4xx_mc_it.c mc_parameters.c hf_registers.c sync_registers.c mcp.c usart_aspep_driver.c dac_ui.c mc_configuration_registers.c aspep.c mc_app_hooks.c foc_app_protocol.c motor_can.c motor_uart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c trajectory_ctrl.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c mcpa.c
    ../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: r3_2_g4xx_pwm_curr_fdbk.c
software components: CMSIS:CORE 4.3.0
